Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010]
File name: 2024_19-01-TP-SK-1_51. T110_320_0_34M.ifc (Edited by Simplebim 9.1 SR6)
Time: 2025-03-24T09:43:55
Author: d.juskevicius
Written by: ODA SDAI 24.6
Made in: Build

# IfcProject, T110_320_0_34M
LongName: T110_320_0_34M

# IfcBuilding, T110_320_0_34M
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m

# IfcBuildingElementProxy: 2
In: T110_320_0_34M
Pset_BuildingElementProxyCommon - Reference: 2
Identifikavimo parametrai - Objekto klasė iš klasifikatoriaus: OL; Atramos numeris: 51; Atramos pavadinimas: T110/320/0/34M; Klasifikatoriaus pavadinimas: LITGRID; Objekto tipas iš klasifikatoriaus: OL-ATR-STB; Pavadinimas: ORO LINIJOS ATRAMA
ePset_Simplebim - Assembly Level: Single

# IfcBuildingElementProxy: 4
In: T110_320_0_34M
Pset_BuildingElementProxyCommon - Reference: 4
ePset_Simplebim - Assembly Level: Single
Identifikavimo parametrai - Objekto klasė iš klasifikatoriaus: OL; Atramos numeris: 51; Atramos pavadinimas: T110/320/0/34M; Pavadinimas: ORO LINIJOS ATRAMOS PAMATAS; Klasifikatoriaus pavadinimas: LITGRID; Objekto tipas iš klasifikatoriaus: AL-ATR-STB
